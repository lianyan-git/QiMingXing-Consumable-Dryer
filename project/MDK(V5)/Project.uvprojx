# Keil uVision project Project.uvprojx, settings and files
target Bootloader (5060960::V5.06 update 7 (build 960)::.\AC5)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00003000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: dryer_bootloader +hex
  AfterMake: fromelf.exe --bin --output ".\Objects\Bootloader\dryer_bootloader.bin" ".\Objects\Bootloader\dryer_bootloader.axf"
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER,BOOTLOADER_BUILD
  c include: ..\..\app;..\..\board;..\..\bootloader;..\..\bsp;..\..\shared;..\..\libraries\CMSIS\CM3\CoreSupport;..\..\libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\libraries\STM32F10x_StdPeriph_Driver\inc;..\..\module
  library: MicroLIB
  memory RVCT4: ROM 0x08000000 size 0x00004800
  memory RVCT9: RAM 0x20000000 size 0x5000
  group System
    ../../libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Entry
    ../../bootloader/: bl_main.c
  group Startup
    ../../libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group Board
    ../../board/: board.c
  group Module
    ../../module/: system_time.c stm32f10x_it.c ota_display.c ota_metadata_store.c ota_boot_request_store.c ota_staging.c
  group Shared
    ../../shared/: ota_contract.c
  group BSP
    ../../bsp/: bsp_spi1_bus.c bsp_w25q128.c sfud.c sfud_port.c bsp_tft_st7789.c bsp_tft_port_stm32.c bsp_internal_flash_stm32.c bsp_esp_uart_stm32.c
  group StdPeriph
    ../../libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_spi.c stm32f10x_flash.c
  group Bootloader
    ../../bootloader/: bl_esp01s.c bl_tft.c flash_ops.c upgrade_flag.c
target APP (5060960::V5.06 update 7 (build 960)::.\AC5)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08005000,0x0000B000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: dryer_app +hex
  AfterMake: fromelf.exe --bin --output ".\Objects\APP\dryer_app.bin" ".\Objects\APP\dryer_app.axf"
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER,VECT_TAB_OFFSET=0x3400,music
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x08003400 size 0x0001CC00
  memory RVCT9: RAM 0x20000000 size 0x5000
  group added to the first target's files
    ../../app/: main.c system_config.c ui_comp.c ui_manager.c
    ../../bsp/: bsp_aht20.c bsp_buzzer.c bsp_can.c bsp_cs1237.c bsp_encoder.c bsp_fan.c bsp_ntc.c bsp_ptc.c bsp_rgb_led.c bsp_stepper.c bsp_system_reset_stm32.c
    ../../libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_i2c.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_tim.c stm32f10x_usart.c
    ../../module/: can_cluster.c esp_at.c esp_http_bridge.c esp_link.c http_server.c mod_ota.c mod_web_server.c mod_wifi_config.c mod_wifi_manager.c music_data.c music_ota.c music_play.c music_store.c ota_http.c ota_update_controller.c ota_upload.c
  group left out of the first target's files
    ../../bootloader/: bl_esp01s.c bl_main.c bl_tft.c flash_ops.c upgrade_flag.c
